# Keil uVision project LPCDTest.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1114/301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: LPCDTest +hex
  c flags: Optim=1
  c include: .\Driver;.\LPCD;.\Middle;.\SRC;.\Driver\Chip;.\Middle\Utility;.\LPCD\inc;.\SRC\Chip
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Source Group 1
    ./: startup_LPC11xx.s
  group Driver
    ./Driver/: fm175xx.c Uart.c
    ./Driver/LPC11xx/: system_LPC11xx.c
    ./Driver/CM0/: core_cm0.c
    ./Driver/Chip/: LPC11XX_SPI.c
  group Middle
    ./Middle/: mifare_card.c type_a.c type_b.c
    ./Middle/Utility/: Utility.c
  group Application
    ./Application/: main.c
  group LPCD
    ./LPCD/src/: lpcd_api.c lpcd_regctrl.c
